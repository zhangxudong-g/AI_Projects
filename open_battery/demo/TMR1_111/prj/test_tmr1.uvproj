# Keil uVision project test_tmr1.uvproj, settings and files
target fun (MCS-51)
  device: F06 SINOMICON
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0-0x2FF) CLOCK(16000000)
  output: io_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../../Library/Include;../../../Library/Source;../../../2_CMSIS;../../../user_com;..\..\..\IIC;..\..\..\DELAY;..\..\..\CONFIG;..\..\..\SW630X
  link misc: REMOVEUNUSED
  group start_up
    ../../../StartUp/: STARTUP_F06.A51
  group main
    ../src/: main.c int.c
    ../../user_com/: user_com.c
    ../../../IIC/: iic_2.c iic_1.c iic_3.c
    ../../../DELAY/: delay.c
    ../../../CONFIG/: config.c
    ../../../SW630X/: SW6301.c SW6303.c

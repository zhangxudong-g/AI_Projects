# Keil uVision project mini_lite.uvproj, settings and files
target fun (MCS-51)
  device: F06 SINOMICON
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0-0x2FF) CLOCK(16000000)
  output: io_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\vendor;..\..\drivers;..\..\user_com
  link misc: REMOVEUNUSED
  group start_up
    ../../vendor/: STARTUP_F06.A51
  group main
    ../src/: main.c int.c
    ../../user_com/: user_com.c
    ../../vendor/: iic_2.c delay.c config.c iic_1.c iic_3.c SW6301.c SW6303.c
